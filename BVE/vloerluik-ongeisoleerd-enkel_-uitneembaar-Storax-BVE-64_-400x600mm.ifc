Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 01627bcf-bdbf-47d8-a1ae-7bdc423f41c5.ifc
Time: 2026-09-11T11:40:20
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, uitneembaar Storax - BVE 64, 400x600mm
In: Bouwlaag
Material: RVS
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAEk2UrYDAAAAouwCAAV2SgAA2FMBAFJfAQCY7AIA-OsCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAOw_AAAFeLkAAGQwAADGpwAAo60AAOnYAAAAAOw_AAAFeLkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAEk2UrYDAAAAouwCAAV2SgAA2FMBAFJfAQCY7AIA-OsCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAOw_AAAFeLkAAGQwAADGpwAAo60AAOnYAAAAAOw_AAAFeLkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 16 kg/st; STABU2: 43.31.10; dagmaatlengte: 400 mm; lengte: 535 mm; NAA.K.T: samengesteld_product_kozijn; Rc-waarde: 0 m²·k/w; breedte: 735 mm; serie: BVE; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; type: 64; dagmaatbreedte: 600 mm; omranding: RVS; luik: RVS
