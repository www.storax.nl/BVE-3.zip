Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 8816766d-bd65-4e9f-a03e-a080b0679335.ifc
Time: 2026-09-11T11:40:02
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, uitneembaar Storax - BVE 55, 500x500mm
In: Bouwlaag
Material: RVS
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAEmgVbYDAAAAouwCAAV2SgAA2FMBAFJfAQCY7AIAbuwCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAOw_AAAFeLkAAGQwAADGpwAAo60AAOnYAAAAAOw_AAAFeLkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAEmgVbYDAAAAouwCAAV2SgAA2FMBAFJfAQCY7AIAbuwCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAOw_AAAFeLkAAGQwAADGpwAAo60AAOnYAAAAAOw_AAAFeLkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 17 kg/st; STABU2: 43.31.10; dagmaatlengte: 500 mm; lengte: 635 mm; NAA.K.T: samengesteld_product_kozijn; Rc-waarde: 0 m²·k/w; breedte: 635 mm; serie: BVE; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; type: 55; dagmaatbreedte: 500 mm; omranding: RVS; luik: RVS
