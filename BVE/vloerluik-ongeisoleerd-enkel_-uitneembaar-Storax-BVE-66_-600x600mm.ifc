Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 6c23b0cc-a1af-4068-917f-640bfb1a28fa.ifc
Time: 2026-09-11T11:40:44
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, uitneembaar Storax - BVE 66, 600x600mm
In: Bouwlaag
Material: RVS
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAElvVbYDAAAAouwCAAV2SgAA2FMBAFJfAQCY7AIAoewCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAOw_AAAFeLkAAGQwAADGpwAAo60AAOnYAAAAAOw_AAAFeLkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAElvVbYDAAAAouwCAAV2SgAA2FMBAFJfAQCY7AIAoewCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAOw_AAAFeLkAAGQwAADGpwAAo60AAOnYAAAAAOw_AAAFeLkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 20 kg/st; STABU2: 43.31.10; dagmaatlengte: 600 mm; lengte: 735 mm; NAA.K.T: samengesteld_product_kozijn; Rc-waarde: 0 m²·k/w; breedte: 735 mm; serie: BVE; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; type: 66; dagmaatbreedte: 600 mm; omranding: RVS; luik: RVS
