Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 8f8058af-b3e0-4e10-ac39-78f97f1fdb9b.ifc
Time: 2026-09-11T11:42:48
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, uitneembaar Storax - BVE 86, 600x800mm
In: Bouwlaag
Material: RVS
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAEleUrYDAAAAouwCAAV2SgAA2FMBAFJfAQCY7AIAkOsCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAOw_AAAFeLkAAGQwAADGpwAAo60AAOnYAAAAAOw_AAAFeLkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAEleUrYDAAAAouwCAAV2SgAA2FMBAFJfAQCY7AIAkOsCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAOw_AAAFeLkAAGQwAADGpwAAo60AAOnYAAAAAOw_AAAFeLkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 24 kg/st; STABU2: 43.31.10; dagmaatlengte: 600 mm; lengte: 735 mm; NAA.K.T: samengesteld_product_kozijn; Rc-waarde: 0 m²·k/w; breedte: 935 mm; serie: BVE; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; type: 86; dagmaatbreedte: 800 mm; omranding: RVS; luik: RVS
